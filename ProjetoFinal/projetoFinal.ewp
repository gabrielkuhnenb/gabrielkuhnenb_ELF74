# IAR project projetoFinal.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: TX_ENABLE_IAR_LIBRARY_SUPPORT
  ICCARM.PreInclude: ..\..\gabrielkuhnenb_ELF74\ProjetoFinal\src\UART_Config.h
  ICCARM.CCIncludePath2: ..\..\..\..; ..\..\TivaWare_C_Series-2.2.0.295; ..\..\ThreadX\common\inc; ..\..\ThreadX\ports\cortex_m4\iar\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: projetoFinal.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../TivaWare_C_Series-2.2.0.295/driverlib/ewarm/Exe/: driverlib.a
    src/: main.c startup_TM4C1294.s system_TM4C1294.c TM4C1294NCPDT.h tx_initialize_low_level.s UART_Config.h
    ../../ThreadX/ports/cortex_m4/iar/example_build/Debug/Exe/: tx.a
    ../../TivaWare_C_Series-2.2.0.295/utils/: uartstdio.c uartstdio.h
